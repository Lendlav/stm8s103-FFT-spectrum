# IAR project IAR_STM8S103F3P6_FFT.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x080
  General.GenHeapSize: 0x080
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: STM8S_SPL\inc; STM8S_SPL\src; FFT; $PROJ_DIR$; src; inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_STM8S103F3P6_FFT.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S103
  ILINK.IlinkOutputFile: IAR_STM8S103F3P6_FFT.out
  group FFT
    FFT/: fft__.c fft__.h
  group SPL
    STM8S_SPL/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
  group User
    src/: init.c main.c SSD1306.c stm8s_it.c
