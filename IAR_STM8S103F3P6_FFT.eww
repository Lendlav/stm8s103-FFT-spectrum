<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAR_STM8S103F3P6_FFT.ewp</path>
  </project>
  <batchBuild/>
</workspace>


